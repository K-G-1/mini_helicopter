# Keil uVision project f072.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f072
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072
  c include: ..\USER;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;..\HARDWARE\LED;..\HARDWARE\delay;..\HARDWARE\IIC;..\HARDWARE\6050;..\HARDWARE\9250;..\HARDWARE\Algorithm\Algorithm_filter;..\HARDWARE\Algorithm\Algorithm_math;..\HARDWARE\Control;..\HARDWARE\IMU;..\HARDWARE\NRF24L01;..\HARDWARE\PWM;..\HARDWARE\SPI;..\HARDWARE\TIM;..\HARDWARE\param;..\HARDWARE\STMFLASH;..\HARDWARE\RC;..\HARDWARE\SAND
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
  group HARDWARE
    ../HARDWARE/6050/: mpu6050.c
    ../HARDWARE/9250/: mpu9250.c
    ../HARDWARE/Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../HARDWARE/Algorithm/Algorithm_math/: Algorithm_math.c
    ../HARDWARE/Control/: control.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/IIC/: IIC.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/param/: param.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RC/: RC.c
    ../HARDWARE/SAND/: sand_data.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TIM/: timer3.c
  group CORE
    ../Libraries/CMSIS/Include/: core_cm0.h
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Include/: system_stm32f0xx.h stm32f0xx.h
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Libraries
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c

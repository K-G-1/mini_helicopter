# Keil uVision project RoboFlyDEMO.uvprojx, settings and files
target RoboFlyDEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Drive\inc;.\IMU;.\CONTROL;.\COMMUNICATE;.\Drive\src\BMP280
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group DRIVE
    ./Drive/src/: led.c delay.c usart.c tim.c nvic.c exit.c iic.c spi.c motor.c fbm320.c mpu6050.c flash.c power.c si24r1.c system.c
    ./Drive/src/BMP280/: bmp280.c
  group IMU
    ./IMU/: filter.c imu.c structconfig.h
  group CONTROL
    ./CONTROL/: pid.c paramsave.c control.c altitude.c
  group COMMUNICATE
    ./COMMUNICATE/: ANO_DT.c remotedata.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

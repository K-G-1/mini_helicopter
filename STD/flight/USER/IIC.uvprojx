# Keil uVision project IIC.uvprojx, settings and files
target IIC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flight +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\6050;..\HARDWARE\9250;..\HARDWARE\Algorithm\Algorithm_filter;..\HARDWARE\Algorithm\Algorithm_math;..\HARDWARE\IIC;..\HARDWARE\IMU;..\HARDWARE\LED;..\HARDWARE\SAND;..\HARDWARE\TIM;..\HARDWARE\Control;..\HARDWARE\RC;..\HARDWARE\PWM;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\STMFLASH;..\HARDWARE\param
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/9250/: mpu9250.c
    ../HARDWARE/IIC/: IIC.c
    ../HARDWARE/TIM/: timer3.c
    ../HARDWARE/SAND/: sand_data.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../HARDWARE/Algorithm/Algorithm_math/: Algorithm_math.c
    ../HARDWARE/Control/: control.c
    ../HARDWARE/RC/: RC.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/6050/: mpu6050.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/param/: param.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_exti.c
  group README
    ../: README.TXT
